# Keil uVision project Project.uvproj, settings and files
target 500W直接半导体V2.0 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 500W直接半导体 +hex
  AfterMake: "E:\Program Files (x86)\Keil_ARM\ARM\BIN40\fromelf.exe" --bin -o ..\Output\Project.bin  ..\Output\Project.axf
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ../User/: main.c Globle.c stm32f10x_conf.h FSMC_FPGA.c USART.c LD_Drive.c stm32f10x_it.c adc.c Timer.c EXIT.c Flash.c ds1302.c DHT12_EEPROM.c modbus.c
  group Note
    ../Note/: readme.txt
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c stm32f10x.h system_stm32f10x.h
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group Peripherals
    ../Libraries/FWlib/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
